# Keil uVision project GD32F450.uvprojx, settings and files
target GD32F450 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F450ZE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\App;..\Hardware\bsp_rtc;..\Hardware\LCD;..\Hardware\RGB;..\Hardware\SDRAM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group App
    ../User/: systick.c
  group Hardware
    ../User/: gd32f4xx_it.c
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/key/: bsp_key.c
    ../Hardware/bsp_rtc/: bsp_rtc.c
    ../Hardware/LCD/: lcd.c
    ../Hardware/SDRAM/: exmc_sdram.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_pmu.c gd32f4xx_spi.c gd32f4xx_exti.c gd32f4xx_crc.c gd32f4xx_misc.c gd32f4xx_dac.c gd32f4xx_exmc.c gd32f4xx_tli.c
  group Doc
    ../Doc/: readme.txt
